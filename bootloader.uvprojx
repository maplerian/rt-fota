# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader
  AfterMake: fromelf --bin !L --output bootloader.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx
  c include: ..\stm32f407-bootloader;.\rt-thread\include;.\rt-thread\components\drivers\include;.\board\CubeMX_Config\Inc;.\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;.\libraries\STM32F4xx_HAL\CMSIS\Include;.\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;.\libraries\HAL_Drivers;.\libraries\HAL_Drivers\config;.\libraries\HAL_Drivers\drv_flash;.\board;.\applications;.\rt-thread\components\drivers\spi\sfud\inc;.\rt-thread\components\drivers\spi;.\packages\fal\inc;.\packages\fal\samples\porting;.\packages\tinycrypt\include;.\packages\quicklz;.\packages\fastlz;.\rt-thread\components\finsh;.\rt-thread\components\utilities\ymodem;.\packages\SignalLed\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ./rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Application
    ./: rtconfig.h
    ./applications/: rt_fota_crc.c main.c rt_fota.c
  group Downloader
    ./packages/downloader/src/: ymodem_ota.c
    ./rt-thread/components/utilities/ymodem/: ymodem.c
  group Drivers
    ./board/: board.c
    ./libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ./board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ./libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
    ./libraries/HAL_Drivers/: drv_gpio.c drv_spi.c drv_rtc.c drv_common.c drv_usart.c drv_wdt.c
  group cpu
    ./rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ./rt-thread/components/drivers/misc/: pin.c
    ./rt-thread/components/drivers/rtc/: rtc.c
    ./rt-thread/components/drivers/serial/: serial.c
    ./rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ./rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ./rt-thread/components/drivers/watchdog/: watchdog.c
    ./rt-thread/components/drivers/src/: completion.c
  group SignalLed
    ./packages/SignalLed/src/: signal_led.c
  group fal
    ./packages/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ./packages/fal/samples/porting/: fal_cfg.h fal_flash_sfud_port.c fal_flash_stm32f4_port.c
  group Finsh
    ./rt-thread/components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group TinyCrypt
    ./packages/tinycrypt/src/: tiny_aes.c
  group Fastlz
    ./packages/fastlz/: fastlz.c
  group Quicklz
    ./packages/quicklz/: quicklz.c
  group STM32_HAL
    ./libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
